# Repository tomeucapo/z80miniframe (continued)

## KiCad design schematics/Z80Allinone/Z80AllInOne/Z80AllInOne.kicad_pcb (continued)

Parts:
C1, C2, C3: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
R1, R2, R3: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: Z80CPU; DIP-40_W15.24mm_LongPads
U2: MAIN RAM; DIP-28_W15.24mm_LongPads
U3: 28C256; DIP-28_W15.24mm_LongPads

Connections:
/BUS Expansion/D0: U1.14 (D0), U2.11 (I/O1), U3.11 (D0); also elsewhere on the board
/BUS Expansion/D1: U1.15 (D1), U2.12 (I/O2), U3.12 (D1); also elsewhere on the board
/BUS Expansion/D2: U1.12 (D2), U2.13 (I/O3), U3.13 (D2); also elsewhere on the board
/BUS Expansion/D3: U1.8 (D3), U2.15 (I/O4), U3.15 (D3); also elsewhere on the board
/BUS Expansion/D4: U1.7 (D4), U2.16 (I/O5), U3.16 (D4); also elsewhere on the board
/BUS Expansion/D5: U1.9 (D5), U2.17 (I/O6), U3.17 (D5); also elsewhere on the board
/BUS Expansion/D6: U1.10 (D6), U2.18 (I/O7), U3.18 (D6); also elsewhere on the board
/BUS Expansion/D7: U1.13 (D7), U2.19 (I/O8), U3.19 (D7); also elsewhere on the board
/BUSACK: U1.23 (~BUSACK); also elsewhere on the board
/BUSRQ: R3.2, U1.25 (~BUSRQ); also elsewhere on the board
/CPU_MEM/RFSH: U1.28 (~RFSH)
/HALT: U1.18 (~HALT); also elsewhere on the board
/IO/A0: U1.30 (A0), U2.10 (A0), U3.10 (A0); also elsewhere on the board
/IO/A1: U1.31 (A1), U2.9 (A1), U3.9 (A1); also elsewhere on the board
/IO/A2: U1.32 (A2), U2.8 (A2), U3.8 (A2); also elsewhere on the board
/IO/A3: U1.33 (A3), U2.7 (A3), U3.7 (A3); also elsewhere on the board
/IO/A4: U1.34 (A4), U2.6 (A4), U3.6 (A4); also elsewhere on the board
/IO/A5: U1.35 (A5), U2.5 (A5), U3.5 (A5); also elsewhere on the board
/IO/A6: U1.36 (A6), U2.4 (A6), U3.4 (A6); also elsewhere on the board
/IO/A7: U1.37 (A7), U2.3 (A7), U3.3 (A7); also elsewhere on the board
/IO/A8: U1.38 (A8), U2.25 (A8), U3.25 (A8); also elsewhere on the board
/IO/A9: U1.39 (A9), U2.24 (A9), U3.24 (A9); also elsewhere on the board
/IO/A10: U1.40 (A10), U2.21 (A10), U3.21 (A10); also elsewhere on the board
/IO/A11: U1.1 (A11), U2.23 (A11), U3.23 (A11); also elsewhere on the board
/IO/A12: U1.2 (A12), U2.2 (A12), U3.2 (A12); also elsewhere on the board
/IO/A13: U1.3 (A13), U2.26 (A13), U3.26 (A13); also elsewhere on the board
/IO/A14: U1.4 (A14), U2.1 (A14), U3.1 (A14); also elsewhere on the board
/IO/A15: U1.5 (A15); also elsewhere on the board
/IORQ: U1.20 (~IORQ); also elsewhere on the board
/M1: U1.27 (~M1); also elsewhere on the board
/MREQ: U1.19 (~MREQ); also elsewhere on the board
/NMI: R1.2, U1.17 (~NMI); also elsewhere on the board
/RAM_CE: U2.20 (/CE); also elsewhere on the board
/RD: U1.21 (~RD), U2.22 (/OE), U3.22 (~OE); also elsewhere on the board
/ROM_CE: U3.20 (~CS); also elsewhere on the board
/WAIT: R2.2, U1.24 (~WAIT); also elsewhere on the board
/WR: U1.22 (~WR), U2.27 (R/W); also elsewhere on the board
/XTAL: U1.6 (~CLK); also elsewhere on the board
//INT: U1.16 (~INT); also elsewhere on the board
//RESET: U1.26 (~RESET); also elsewhere on the board
GND: C1.2, C2.1, C3.1, U1.29 (GND), U2.14 (GND), U3.14 (GND); also elsewhere on the board
VCC: C1.1, C2.2, C3.2, R1.1, R2.1, R3.1, U1.11 (VCC), U2.28 (VDD), U3.27 (~WE), U3.28 (VCC); also elsewhere on the board

Parts:
C5, C6, C9, C10: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C7, C8: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C11, C12: 47pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C13: 0.47uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C41: 10uF; CP_Radial_D5.0mm_P2.50mm
D1: LED_PC1; LED_D3.0mm
D2: LED_PC0; LED_D3.0mm
FB1: 600Ohm; L_0805_2012Metric
J1: USB_B_Micro; USB_Mini-B_Lumberg_2486_01_Horizontal
J2: USER_IO_CONN; EdgeConector_18pin
JP1: USB_POWER_SW; PinHeader_1x02_P2.54mm_Vertical
JP2: USB POWER/EXT POWER; PinHeader_1x03_P2.54mm_Vertical
Q1: IRLML6402; SOT-23
R4, R5, R6, R7: 1K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DIP_x04; DIP-8_W7.62mm_LongPads
U4: 82C55A; DIP-40_W15.24mm
U5: 16550; DIP-40_W15.24mm
U6: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm
U13: 7400; DIP-14_W7.62mm_LongPads

Connections:
/BUS Expansion/D0: U4.34 (D0), U5.1 (D0); also elsewhere on the board
/BUS Expansion/D1: U4.33 (D1), U5.2 (D1); also elsewhere on the board
/BUS Expansion/D2: U4.32 (D2), U5.3 (D2); also elsewhere on the board
/BUS Expansion/D3: U4.31 (D3), U5.4 (D3); also elsewhere on the board
/BUS Expansion/D4: U4.30 (D4), U5.5 (D4); also elsewhere on the board
/BUS Expansion/D5: U4.29 (D5), U5.6 (D5); also elsewhere on the board
/BUS Expansion/D6: U4.28 (D6), U5.7 (D6); also elsewhere on the board
/BUS Expansion/D7: U4.27 (D7), U5.8 (D7); also elsewhere on the board
/DSR: U5.37 (~DSR), U5.38 (~DCD), U6.2 (DTR); also elsewhere on the board
/DTR: U5.33 (~DTR), U6.9 (DCR), U6.10 (DCD); also elsewhere on the board
/IO/A0: U4.9 (A0), U5.28 (A0); also elsewhere on the board
/IO/A1: U4.8 (A1), U5.27 (A1); also elsewhere on the board
/IO/A2: U5.26 (A2); also elsewhere on the board
/IO/Casette Interface/PC2: U4.16 (PC2); also elsewhere on the board
/IO/Casette Interface/PC3: U4.17 (PC3); also elsewhere on the board
/IO/Casette Interface/PC4: U4.13 (PC4); also elsewhere on the board
/IO/Casette Interface/PC5: U4.12 (PC5); also elsewhere on the board
/IO/Casette Interface/PC6: U4.11 (PC6); also elsewhere on the board
/IO/Casette Interface/PC7: U4.10 (PC7); also elsewhere on the board
/IO/PA4: J2.1, U4.40 (PA4)
/IO/PA5: J2.3, U4.39 (PA5)
/IO/PA6: U4.38 (PA6); also elsewhere on the board
/IO/PA7: U4.37 (PA7); also elsewhere on the board
/IO/PB0: J2.9, U4.18 (PB0)
/IO/PB1: J2.2, U4.19 (PB1)
/IO/PB2: J2.4, U4.20 (PB2)
/IO/PB3: J2.6, U4.21 (PB3)
/IO/PB4: J2.5, U4.22 (PB4)
/IO/PB5: J2.8, U4.23 (PB5)
/IO/PB6: J2.7, U4.24 (PB6)
/IO/PB7: J2.10, U4.25 (PB7)
/IO/PC0: R9.2, U4.14 (PC0)
/IO/PC1: R8.2, U4.15 (PC1)
/PPI_CE: U4.6 (~CS); also elsewhere on the board
/RD: U4.5 (~RD), U5.21 (~RD); also elsewhere on the board
/RESET_IO: U4.35 (RESET), U5.35 (MR); also elsewhere on the board
/RX: U5.10 (SIN), U6.1 (TXD); also elsewhere on the board
/TX: U5.11 (SOUT), U6.5 (RXD); also elsewhere on the board
/UART_CE: U5.14 (~CS2); also elsewhere on the board
/UART_INT: U13.11; also elsewhere on the board
/WR: U4.36 (~WR), U5.18 (~WR); also elsewhere on the board
/XTAL: U5.16 (XIN); also elsewhere on the board
GND: C5.1, C6.1, C7.1, C9.2, C10.1, C11.1, C12.1, C13.2, C41.2, D1.1 (K), D2.1 (K), J1.5 (GND), J2.11, R4.2, R5.2, R6.2, R7.2, U4.7 (GND), U5.19 (WR), U5.20 (GND), U5.22 (RD), U5.25 (~ADS), U6.7 (GND), U6.18 (GND), U6.21 (GND), U6.25 (AGND), U6.26 (TEST); also elsewhere on the board
unnamed: C7.2, C8.2, JP2.1 (A), Q1.3 (D)
unnamed: C8.1, Q1.1 (G), R10.2
unnamed: C9.1, U6.17 (3V3OUT)
unnamed: C11.2, J1.3 (D+), U6.15 (USBD+)
unnamed: C12.2, J1.2 (D-), U6.16 (USBD-)
unnamed: C13.1, J1.6 (Shield)
unnamed: C41.1, FB1.1, JP1.2 (B)
unnamed: D1.2 (A), R8.1
unnamed: D2.2 (A), R9.1
unnamed: FB1.2, JP2.3 (B), Q1.2 (S), U6.4 (VCCIO), U6.20 (VCC)
unnamed: J1.1 (VBUS), JP1.1 (A)
unnamed: R4.1, SW1.1, U4.4 (PA0)
unnamed: R5.1, SW1.2, U4.3 (PA1)
unnamed: R6.1, SW1.3, U4.2 (PA2)
unnamed: R7.1, SW1.4, U4.1 (PA3)
unnamed: R10.1, U6.14 (CBUS3)
unnamed: U5.9 (RCLK), U5.15 (~BAUDOUT)
unnamed: U5.32 (~RTS), U6.11 (CTS)
unnamed: U5.36 (~CTS), U6.3 (RTS)
unnamed: U5.30 (INTR), U13.12, U13.13
VCC: C5.2, C6.2, C10.2, J2.12, JP2.2 (C), SW1.5, SW1.6, SW1.7, SW1.8, U4.26 (VCC), U5.12 (CS0), U5.13 (CS1), U5.39 (~RI), U5.40 (VCC), U6.19 (~RESET); also elsewhere on the board

Notes on the sheet:
Mini Z80 IO Module
24 /07/2022

Schematic: casette_interface.kicad_sch

Parts:
C47, C48, C49, C51: C_Disc_D7.0mm_W2.5mm_P5.00mm
C50: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
D7, D8, D9, D10: D_DO-35_SOD27_P7.62mm_Horizontal
J6: CASETTE/AUDIO; DIN-5
K1: ADW11; Relay_1P1T_NO_10x24x18.8mm_Panasonic_ADW11xxxxW_THT
Q4: BC337; TO-92_Inline
R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41: R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U18: DIP-14_W7.62mm_LongPads
U19: DIP-8_W7.62mm_LongPads

Connections:
/IO/Casette Interface/M1: C47.2, D8.2 (K), J6.1, K1.3, K1.14
/IO/Casette Interface/M2: C47.1, D9.2 (K), J6.3, K1.5, K1.11
/IO/Casette Interface/PC2: U18.13; also elsewhere on the board
/IO/Casette Interface/PC4: U18.9; also elsewhere on the board
/IO/Casette Interface/PC5: U18.5; also elsewhere on the board
/IO/Casette Interface/PC6: U18.3; also elsewhere on the board
/IO/Casette Interface/PC7: U18.1; also elsewhere on the board
/IO/PA6: R34.1, R35.2, U19.1; also elsewhere on the board
/IO/PA7: R24.2; also elsewhere on the board
GND: C48.2, C49.2, C50.2, C51.1, D10.1 (A), J6.2, Q4.3 (E), R33.1, R37.1, R41.1, U18.7 (GND), U19.8 (V+); also elsewhere on the board
unnamed: C48.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.2, R32.2
unnamed: C49.1, J6.5, R32.1, R33.2
unnamed: C51.2, J6.4, R40.2, R41.2
unnamed: D7.1 (A), K1.6, K1.A2, Q4.1 (C)
unnamed: D8.1 (A), D9.1 (A)
unnamed: D10.2 (K), R39.2, R40.1
unnamed 182: U18.11; also elsewhere on the board
unnamed: Q4.2 (B), R24.1
unnamed: R25.2, U18.2
unnamed: R26.2, U18.4
unnamed: R27.2, U18.6
unnamed: R28.2, U18.8
unnamed: R29.2, U18.10
unnamed: R30.2, U18.12
unnamed: R35.1, R36.1, R37.2, U19.2 (-)
unnamed: R38.1, R39.1, U19.3 (+)
VCC: C50.1, D7.2 (K), K1.1, K1.A1, R31.1, R34.2, R36.2, R38.2, U18.14 (VCC), U19.4 (V-); also elsewhere on the board

Board: 2 copper layers, 389.9 x 174.0 mm, 166 parts (0 on the bottom side), 226 nets.

Other parts of the board:
JP6: INTRA; PinHeader_1x03_P2.54mm_Vertical

Their connections:
/IO/Casette Interface/PC3: JP6.2 (C); also elsewhere on the board
/PPI_INT: JP6.3 (B); also elsewhere on the board
unnamed 182: JP6.1 (A); also elsewhere on the board

## KiCad design schematics/Z80Mini/Casette/casette_interface/casette_interface.kicad_pcb

Parts:
C1: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 0.002uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3, C6: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4: DIODE; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Conn_02x10_Odd_Even; IDC-Header_2x10_P2.54mm_Horizontal
J2: CASETTE; DIN-5-180.kicad_mod
K1: DIPxx-1Axx-13x; Relay_StandexMeder_DIP_LowProfile
Q1: BC140; TO-39-3
R1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 40K2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 80K6; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 160K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 330K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R11, R12, R13, R14, R15, R16, R17, R18: 68K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: 74LS07; DIP-14_W7.62mm_LongPads
U2: LM393; DIP-8_W7.62mm_Socket_LongPads

Connections:
/M1: C3.2, D1.2 (K), J2.1, K1.8
/M2: C3.1, D2.2 (K), J2.3, K1.14
/PA6: J1.12, R11.1, R13.2, U2.1
/PA7: J1.11, R10.2
/PC0: J1.2
/PC1: J1.3
/PC2: J1.4, U1.13
/PC3: J1.5, U1.11
/PC4: J1.6, U1.9
/PC5: J1.7, U1.5
/PC6: J1.8, U1.3
/PC7: J1.9, U1.1
GND: C1.2, C2.2, C4.2, C6.1, D4.1 (A), J1.10, J2.2, Q1.1 (E), R9.1, R17.1, R18.1, U1.7 (GND), U2.8 (V+)
unnamed: C1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.2, R8.2
unnamed: C2.1, J2.5, R8.1, R9.2
unnamed: C6.2, J2.4, R16.2, R18.2
unnamed: D1.1 (A), D2.1 (A)
unnamed: D3.1 (A), K1.2, Q1.3 (C)
unnamed: D4.2 (K), R15.2, R16.1
unnamed: Q1.2 (B), R10.1
unnamed: R1.2, U1.2
unnamed: R2.2, U1.4
unnamed: R3.2, U1.6
unnamed: R4.2, U1.8
unnamed: R5.2, U1.10
unnamed: R6.2, U1.12
unnamed: R12.1, R13.1, R17.2, U2.2 (-)
unnamed: R14.1, R15.1, U2.3 (+)

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
Board: 2 copper layers, 33 parts (0 on the bottom side), 27 nets.

## KiCad design schematics/Z80Mini/serial_adapter/serialadapter/serialadapter.kicad_pcb

Board: 2 copper layers, 86.4 x 57.1 mm, 25 parts (0 on the bottom side), 31 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C9: 47uF; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1: URX; LED_D3.0mm
D2: UTX; LED_D3.0mm
J1: TTL Serial; PinHeader_1x06_P2.54mm_Vertical
J2: RS232; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J3: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
J4: I2C; PinHeader_1x03_P2.54mm_Vertical
JP1: USB_SEL; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
REF1, REF2: MountingHole_3.2mm_M3_DIN965_Pad
U1: MAX3222CPN+; DIP-18_W7.62mm
U2: 74LS365; DIP-16_W7.62mm
U3: MCP2221A-I_SL; DIP-14_W7.62mm_Socket

Connections:
/ENABLE: JP1.2, U1.1, U2.1, U2.15, U3.4
/LED_URX: D1.1, U3.2
/LED_UTX: D2.1, U3.3
/RX: J1.6, U2.3, U3.6
/TX: J1.4, U2.6, U3.5
GND: C1.1, C2.1, C3.1, C6.1, C7.1, C8.1, C9.1, J1.2, J2.5, J3.4, J4.3, JP1.3, REF1.1, REF2.1, U1.16, U2.8, U3.14
unnamed: C2.2, U1.7
unnamed: C3.2, U1.3
unnamed: C4.1, U1.2
unnamed: C4.2, U1.4
unnamed: C5.1, U1.5
unnamed: C5.2, U1.6
unnamed: C6.2, U3.11
unnamed: C9.2, J3.5
unnamed: D1.2, R3.2
unnamed: D2.2, R4.2
unnamed: J1.3, U2.10
unnamed: J1.5, U2.5
unnamed: J2.2, U1.15
unnamed: J2.3, U1.14
unnamed: J2.4, U1.9
unnamed: J2.6, U1.8
unnamed: J3.2, U3.12
unnamed: J3.3, U3.13
unnamed: J4.1, R1.2, U3.10
unnamed: J4.2, R2.2, U3.9
unnamed: U1.10, U2.4
unnamed: U1.11, U2.9
unnamed: U1.12, U2.7
unnamed: U1.13, U2.2
VCC: C1.2, C7.2, C8.2, J1.1, JP1.1, R1.1, R2.1, R3.1, R4.1, U1.17, U1.18, U2.16, U3.1

## KiCad design schematics/Z80Mini/backplane/Z80Backplane/Z80Backplane.kicad_pcb

Board: 2 copper layers, 161.3 x 94.0 mm, 38 parts (0 on the bottom side), 69 nets.

Parts:
C1: 47uF; C_Radial_D6.3mm_H5.0mm_P2.50mm
C2: 4.7uF; C_Radial_D6.3mm_H5.0mm_P2.50mm
C3, C4, C5, C6: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1: DIODE; D_A-405_P7.62mm_Horizontal
D2: LED; LED_D3.0mm
D3: LED_HALT; LED_D3.0mm
D4: LED_M1; LED_D3.0mm
D5: LED_CF_ACTIV; LED_D3.0mm
J1: CPU-IO BOARD; ConnectorEdge40_Female
J2: GRAPHICS_SOUND_CARD; ConnectorEdge40_Female
J3: EXPANSION_1; ConnectorEdge40_Female
J4: EXPANSION_2; ConnectorEdge40_Female
J5: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J6: BUS; IDC-Header_2x20_P2.54mm_Vertical
J7: CF Card IDE; PinHeader_2x20_P2.00mm_Vertical
J8: IOCS7; PinHeader_1x01_P2.54mm_Vertical
JP1: Barrel_Jack_Switch; BarrelJack_Wuerth_6941xx301002
JP2, JP3: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
REF1, REF2, REF3, REF4, REF5: MountingHole_3mm_Pad
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: L7805; TO-126-3_Horizontal_TabDown
U2: 74LS138; DIP-16_W7.62mm_Socket
U3: 74LS139; DIP-16_W7.62mm_Socket
U4, U5: 74HC00; DIP-14_W7.62mm

Connections:
/A0: J1.19, J2.19, J3.19, J4.19, J6.19, J7.35
/A1: J1.20, J2.20, J3.20, J4.20, J6.20, J7.33
/A2: J1.21, J2.21, J3.21, J4.21, J6.21, J7.36
/A3: J1.22, J2.22, J3.22, J4.22, J6.22
/A4: J1.23, J2.23, J3.23, J4.23, J6.23
/A5: J1.24, J2.24, J3.24, J4.24, J6.24, U2.1
/A6: J1.25, J2.25, J3.25, J4.25, J6.25, U2.2
/A7: J1.26, J2.26, J3.26, J4.26, J6.26, U2.3
/A8: J1.27, J2.27, J3.27, J4.27, J6.27, U2.6, U3.1
/A9: J1.28, J2.28, J3.28, J4.28, J6.28
/A10: J1.29, J2.29, J3.29, J4.29, J6.29
/A11: J1.30, J2.30, J3.30, J4.30, J6.30
/A12: J1.31, J2.31, J3.31, J4.31, J6.31
/A13: J1.37, J2.37, J3.37, J4.37, J6.37
/A14: J1.38, J2.38, J3.38, J4.38, J6.38
/A15: J1.39, J2.39, J3.39, J4.39, J6.39
/BUSACK: J1.32, J2.32, J3.32, J4.32, J6.32
/BUSRQ: J1.35, J2.35, J3.35, J4.35, J6.35, SW1.2
/D0: J1.10, J2.10, J3.10, J4.10, J6.10, J7.17
/D1: J1.11, J2.11, J3.11, J4.11, J6.11, J7.15
/D2: J1.12, J2.12, J3.12, J4.12, J6.12, J7.13
/D3: J1.13, J2.13, J3.13, J4.13, J6.13, J7.11
/D4: J1.14, J2.14, J3.14, J4.14, J6.14, J7.9
/D5: J1.15, J2.15, J3.15, J4.15, J6.15, J7.7
/D6: J1.16, J2.16, J3.16, J4.16, J6.16, J7.5
/D7: J1.17, J2.17, J3.17, J4.17, J6.17, J7.3
/HALT: J1.3, J2.3, J3.3, J4.3, J6.3, U5.4, U5.5
/INT: J1.40, J2.40, J3.40, J4.40, J6.40
/IOCS0: J3.33, U2.15
/IOCS6: J7.37, U2.9
/IORD: J7.25, U4.8
/IORQ: J1.6, J2.6, J3.6, J4.6, J6.6, U2.4, U2.5, U4.4, U4.5
/IOWR: J7.23, U4.11
/M1: J1.7, J2.7, J3.7, J4.7, J6.7, U5.9, U5.10
/MR: J7.1, U5.11
/MREQ: J1.1, J2.1, J3.1, J4.1, J6.1
/NMI: J1.2, J2.2, J3.2, J4.2, J6.2
/RD: J1.8, J2.8, J3.8, J4.8, J6.8, U4.1, U4.2
/RESET: J1.5, J2.5, J3.5, J4.5, J6.5, U5.12, U5.13
/SND_SEL: J1.36, JP3.3, U3.2
/SND_SEL1: J2.36, JP3.2
/VDP_SEL: J1.33, JP2.3, U3.3
/VDP_SEL1: J2.33, JP2.2
/WAIT: J1.4, J2.4, J3.4, J4.4, J6.4
/WR: J1.18, J2.18, J3.18, J4.18, J6.18, U5.1, U5.2
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, D2.1, D3.1, D4.1, J1.34, J2.34, J3.34, J4.34, J5.1, J6.34, J7.2, J7.19, J7.22, J7.24, J7.26, J7.30, J7.40, JP1.1, REF2.2, REF3.3, SW1.1, U1.2, U2.8, U3.8, U4.7, U5.7
unnamed: C1.1, D1.2, U1.1
unnamed: D1.1, JP1.3
unnamed: D2.2, R1.2
unnamed: D3.2, R2.1
unnamed: D4.2, R3.1
unnamed: D5.1, R4.1
unnamed: J3.36, U2.14
unnamed: J4.33, U2.13
unnamed: J4.36, U2.12
unnamed: J5.2, JP1.2
unnamed: J6.33, U2.11
unnamed: J6.36, U2.10
unnamed: J7.38, R5.1
unnamed: J7.39, R4.2
unnamed: J8.1, U2.7
unnamed: JP2.1, U3.5
unnamed: JP3.1, U3.6
unnamed: R2.2, U5.6
unnamed: R3.2, U5.8
unnamed: U4.3, U4.9
unnamed: U4.6, U4.10, U4.12
unnamed: U4.13, U5.3
VCC: C2.1, C3.2, C4.2, C5.2, C6.2, D5.2, J1.9, J2.9, J3.9, J4.9, J6.9, J7.20, R1.1, R5.2, SW1.3, U1.3, U2.16, U3.16, U4.14, U5.14

## KiCad design schematics/Z80Mini/Z80MiniFrameProtoConn/Z80MiniFrameProtoConn.kicad_pcb

Parts:
J1: Z80MiniFrame BUS; IDC-Header_2x20_P2.54mm_Vertical
J2: ROW1; PinHeader_1x20_P2.54mm_Vertical
J3: ROW2; PinHeader_1x20_P2.54mm_Vertical
J4: DATA; PinHeader_1x08_P2.54mm_Vertical

Connections:
/D0: J1.10, J3.5, J4.1
/D1: J1.11, J2.6, J4.2
/D2: J1.12, J3.6, J4.3
/D3: J1.13, J2.7, J4.4
/D4: J1.14, J3.7, J4.5
/D5: J1.15, J2.8, J4.6
/D6: J1.16, J3.8, J4.7
/D7: J1.17, J2.9, J4.8
GND: J1.34, J3.17
unnamed: J1.1, J2.1
unnamed: J1.2, J3.1
unnamed: J1.3, J2.2
unnamed: J1.4, J3.2
unnamed: J1.5, J2.3
unnamed: J1.6, J3.3
unnamed: J1.7, J2.4
unnamed: J1.8, J3.4
unnamed: J1.18, J3.9
unnamed: J1.19, J2.10
unnamed: J1.20, J3.10
unnamed: J1.21, J2.11
unnamed: J1.22, J3.11
unnamed: J1.23, J2.12
unnamed: J1.24, J3.12
unnamed: J1.25, J2.13
unnamed: J1.26, J3.13
unnamed: J1.27, J2.14
unnamed: J1.28, J3.14
unnamed: J1.29, J2.15
unnamed: J1.30, J3.15
unnamed: J1.31, J2.16
unnamed: J1.32, J3.16
unnamed: J1.33, J2.17
unnamed: J1.35, J2.18
unnamed: J1.36, J3.18
unnamed: J1.37, J2.19
unnamed: J1.38, J3.19
unnamed: J1.39, J2.20
unnamed: J1.40, J3.20
VCC: J1.9, J2.5

Board: 2 copper layers, 35.6 x 68.6 mm, 4 parts (0 on the bottom side), 40 nets.
