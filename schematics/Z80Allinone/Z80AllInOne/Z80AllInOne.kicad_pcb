# Repository tomeucapo/z80miniframe

File README.md:

# Z80MiniFrame
Core firmware source code and schematics from Z80MiniFrame hardware. This is a Z80 based microcomputer based system.

## Features

### Hardware 

* 32KBytes EEPROM for Firmware routines and Z80 MS-BASIC
* 32KBytes RAM
* VDP TMS9918
* PSG AY-3-8910
* USB-Serial Console Interface

### Software

* Extend BASIC instructions to support VDP capabilities like: COLOR, SCREEN or LOCATE instructions.
* Created RST $20 routine service to call firmware routines like VDP routines.

## Required tools
This project uses ZMAC Z80 Macro assembler and LD80 Linker from http://48k.ca/zmac.html. And finally needs make or nmake or Make to build project.

## Build software
```
nmake all
```

This produces firmware.hex into bin directory and this file can burn into 32KBytes EEPROM like AT28C256.

## KiCad design schematics/Z80Allinone/Z80AllInOne/Z80AllInOne.kicad_pcb

Parts:
C4, C14, C15, C27, C39, C52: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C44, C45: 0.1uF; C_Radial_D6.3mm_H5.0mm_P2.50mm
C53: 100uF; CP_Radial_D8.0mm_P3.80mm
C54: 10uF; CP_Radial_D8.0mm_P3.80mm
D3, D12: DIODE; D_A-405_P7.62mm_Horizontal
D6: LED_POWER; LED_D3.0mm
D11: LED_CF_ACTIV; LED_D3.0mm
J4: TTL SERIAL; PinHeader_1x06_P2.54mm_Vertical
J5: USR_INTR; PinHeader_1x04_P2.54mm_Vertical
J8: TRGS/TOS; PinHeader_1x07_P2.54mm_Vertical
J10: CF Card IDE; IDC-Header_2x20_P2.54mm_Vertical
JP4: MREQ/A8; PinHeader_1x03_P2.54mm_Vertical
JP5: 9VDC; BarrelJack_Wuerth_6941xx301002
R11: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R42: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R43, R44: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U13: 7400; DIP-14_W7.62mm_LongPads
U14: 74LS138; DIP-16_W7.62mm_LongPads
U15: 74LS139; DIP-16_W7.62mm_Socket
U24: Z80-CTC; DIP-28_W15.24mm_LongPads
U27: 74HC00; DIP-14_W7.62mm
U29: L7805; TO-220-3_Horizontal_TabDown
X1: 4MHz; Oscillator_DIP-8

Connections:
/BUS Expansion/D0: J10.17, U24.25 (D0); also elsewhere on the board
/BUS Expansion/D1: J10.15, U24.26 (D1); also elsewhere on the board
/BUS Expansion/D2: J10.13, U24.27 (D2); also elsewhere on the board
/BUS Expansion/D3: J10.11, U24.28 (D3); also elsewhere on the board
/BUS Expansion/D4: J10.9, U24.1 (D4); also elsewhere on the board
/BUS Expansion/D5: J10.7, U24.2 (D5); also elsewhere on the board
/BUS Expansion/D6: J10.5, U24.3 (D6); also elsewhere on the board
/BUS Expansion/D7: J10.3, U24.4 (D7); also elsewhere on the board
/CF_CE: J10.37, U14.10 (O5)
/CTC_CE: U14.11 (O4), U24.16 (~CE)
/CTC_INT: U24.12 (~INT); also elsewhere on the board
/DEV_CS1: U14.9 (O6); also elsewhere on the board
/DSR: J4.5; also elsewhere on the board
/DTR: J4.3; also elsewhere on the board
/INT_DEV3: J5.1; also elsewhere on the board
/INT_DEV4: J5.2; also elsewhere on the board
/INT_DEV5: J5.3; also elsewhere on the board
/IO/A0: J10.35, U24.18 (CS0); also elsewhere on the board
/IO/A1: J10.33, U24.19 (CS1); also elsewhere on the board
/IO/A2: J10.36; also elsewhere on the board
/IO/A5: U14.1 (A0); also elsewhere on the board
/IO/A6: U14.2 (A1); also elsewhere on the board
/IO/A7: U14.3 (A2); also elsewhere on the board
/IO/A8: U13.1, U13.2; also elsewhere on the board
/IO/A15: U15.2 (A); also elsewhere on the board
/IORD: J10.25, U27.8
/IORQ: U14.4 (E1), U14.5 (E2), U24.10 (~IORQ), U27.4, U27.5; also elsewhere on the board
/IOWR: J10.23, U27.11
/M1: U24.14 (~M1); also elsewhere on the board
/MR: J10.1, U13.6
/MREQ: JP4.1 (A), U15.1 (~EN); also elsewhere on the board
/NMI: J5.4; also elsewhere on the board
/PPI_CE: U14.15 (O0); also elsewhere on the board
/PSG_CE: U14.12 (O3); also elsewhere on the board
/RAM_CE: U15.5 (~Q1); also elsewhere on the board
/RD: U13.9, U13.10, U24.6 (~RD); also elsewhere on the board
/ROM_CE: U15.4 (~Q0); also elsewhere on the board
/RX: J4.6; also elsewhere on the board
/TX: J4.4; also elsewhere on the board
/UART_CE: U14.14 (O1); also elsewhere on the board
/VDP_CE: U14.13 (O2); also elsewhere on the board
/WR: U27.1, U27.2; also elsewhere on the board
/XTAL: U24.15 (CLK), X1.5 (OUT); also elsewhere on the board
//RESET: U13.4, U13.5, U24.17 (~RES); also elsewhere on the board
GND: C4.1, C14.2, C15.2, C27.2, C39.2, C44.2, C45.2, C52.1, C53.2, C54.2, D6.1 (K), J4.2, J10.2, J10.19, J10.22, J10.24, J10.26, J10.30, J10.40, JP5.2, JP5.3, U13.7 (GND), U14.8 (GND), U15.3 (B), U15.8 (GND), U24.5 (GND), U27.7 (GND), U29.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: C44.1, C53.1, D3.2 (A), D12.2 (A), U29.1 (IN)
unnamed: D3.1 (K), JP5.1
unnamed: D6.2 (A), R11.2
unnamed: D11.1 (K), R43.1
unnamed: J8.1, U24.20 (CK/TRG3)
unnamed: J8.2, U24.9 (ZC/TO2)
unnamed: J8.3, U24.21 (CK/TRG2)
unnamed: J8.4, U24.8 (ZC/TO1)
unnamed: J8.5, U24.22 (CK/TRG1)
unnamed: J8.6, U24.7 (ZC/TO0)
unnamed: J8.7, U24.23 (CK/TRG0)
unnamed: J10.38, R44.1
unnamed: J10.39, R43.2
unnamed: JP4.2 (C), U14.6 (E3)
unnamed: JP4.3 (B), U13.3
unnamed: R42.1, U24.13 (IEI)
unnamed: U13.8, U27.9
unnamed: U27.6, U27.10, U27.12
unnamed: U27.3, U27.13
VCC: C4.2, C14.1, C15.1, C27.1, C39.1, C45.1, C52.2, C54.1, D11.2 (A), D12.1 (K), J4.1, J10.20, R11.1, R42.2, R44.2, U13.14 (VCC), U14.16 (VCC), U15.16 (VCC), U24.24 (VDD), U27.14 (VCC), U29.3 (OUT), X1.8 (Vcc); also elsewhere on the board

Parts:
C37: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
C38, C40: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
JP3: IM2_SEL; PinHeader_1x02_P2.54mm_Vertical
RN1: R_Network08; R_Array_SIP9
U25: 74LS32; DIP-14_W7.62mm_LongPads
U26: 74LS148; DIP-16_W7.62mm_LongPads
U28: 74LS373; DIP-20_W7.62mm_LongPads

Connections:
/BUS Expansion/D0: U28.2 (O0); also elsewhere on the board
/BUS Expansion/D1: U28.5 (O1); also elsewhere on the board
/BUS Expansion/D2: U28.6 (O2); also elsewhere on the board
/BUS Expansion/D3: U28.9 (O3); also elsewhere on the board
/BUS Expansion/D4: U28.12 (O4); also elsewhere on the board
/BUS Expansion/D5: U28.15 (O5); also elsewhere on the board
/BUS Expansion/D6: U28.16 (O6); also elsewhere on the board
/BUS Expansion/D7: U28.19 (O7); also elsewhere on the board
/CTC_INT: RN1.2 (R1), U26.10 (IO); also elsewhere on the board
/INT_DEV1: RN1.5 (R4), U26.13 (I3); also elsewhere on the board
/INT_DEV3: RN1.7 (R6), U26.2 (I5); also elsewhere on the board
/INT_DEV4: RN1.8 (R7), U26.3 (I6); also elsewhere on the board
/INT_DEV5: RN1.9 (R8), U26.4 (I7); also elsewhere on the board
/IORQ: U25.2; also elsewhere on the board
/M1: U25.1, U28.11 (LE); also elsewhere on the board
/PPI_INT: RN1.6 (R5), U26.1 (I4); also elsewhere on the board
/UART_INT: RN1.3 (R2), U26.11 (I1); also elsewhere on the board
/VDP_INT: RN1.4 (R3), U26.12 (I2); also elsewhere on the board
//INT: U25.11; also elsewhere on the board
GND: C37.1, C38.2, C40.2, U25.7 (GND), U26.5 (EI), U26.8 (GND), U28.3 (D0), U28.10 (GND), U28.13 (D4), U28.14 (D5), U28.17 (D6), U28.18 (D7); also elsewhere on the board
unnamed: JP3.1 (A), U25.6
unnamed: JP3.2 (B), U28.1 (OE)
unnamed: U25.3, U25.4
unnamed: U25.5, U25.9, U25.10, U26.14 (GS)
unnamed: U25.8, U25.12, U25.13
unnamed: U26.6 (S2), U28.8 (D3)
unnamed: U26.7 (S1), U28.7 (D2)
unnamed: U26.9 (S0), U28.4 (D1)
VCC: C37.2, C38.1, C40.1, RN1.1 (common), U25.14 (VCC), U26.16 (VCC), U28.20 (VCC); also elsewhere on the board

Parts:
JE1: EXPANSION_BUS; EdgeConector_40pin

Connections:
/BUS Expansion/D0: JE1.10; also elsewhere on the board
/BUS Expansion/D1: JE1.11; also elsewhere on the board
/BUS Expansion/D2: JE1.12; also elsewhere on the board
/BUS Expansion/D3: JE1.13; also elsewhere on the board
/BUS Expansion/D4: JE1.14; also elsewhere on the board
/BUS Expansion/D5: JE1.15; also elsewhere on the board
/BUS Expansion/D6: JE1.16; also elsewhere on the board
/BUS Expansion/D7: JE1.17; also elsewhere on the board
/BUSACK: JE1.32; also elsewhere on the board
/BUSRQ: JE1.35; also elsewhere on the board
/DEV_CS1: JE1.36; also elsewhere on the board
/HALT: JE1.3; also elsewhere on the board
/INT_DEV1: JE1.40; also elsewhere on the board
/IO/A0: JE1.19; also elsewhere on the board
/IO/A1: JE1.20; also elsewhere on the board
/IO/A2: JE1.21; also elsewhere on the board
/IO/A3: JE1.22; also elsewhere on the board
/IO/A4: JE1.23; also elsewhere on the board
/IO/A5: JE1.24; also elsewhere on the board
/IO/A6: JE1.25; also elsewhere on the board
/IO/A7: JE1.26; also elsewhere on the board
/IO/A8: JE1.27; also elsewhere on the board
/IO/A9: JE1.28; also elsewhere on the board
/IO/A10: JE1.29; also elsewhere on the board
/IO/A11: JE1.30; also elsewhere on the board
/IO/A12: JE1.31; also elsewhere on the board
/IO/A13: JE1.37; also elsewhere on the board
/IO/A14: JE1.38; also elsewhere on the board
/IO/A15: JE1.39; also elsewhere on the board
/IORQ: JE1.6; also elsewhere on the board
/M1: JE1.7; also elsewhere on the board
/MREQ: JE1.1; also elsewhere on the board
/NMI: JE1.2; also elsewhere on the board
/RD: JE1.8; also elsewhere on the board
/WAIT: JE1.4; also elsewhere on the board
/WR: JE1.18; also elsewhere on the board
/XTAL: JE1.33; also elsewhere on the board
//RESET: JE1.5; also elsewhere on the board
GND: JE1.34; also elsewhere on the board
VCC: JE1.9; also elsewhere on the board

Parts:
C34, C35, C46: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C36: 10uF; CP_Radial_D5.0mm_P2.50mm
D4: LED_RESET; LED_D3.0mm
Q3: BC337; TO-92_Inline
R16: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R20: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R23: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW2: RESET; SW_PUSH_6mm_H5mm
U12: 7400; DIP-14_W7.62mm_LongPads
U23: NA555P; DIP-8_W7.62mm

Connections:
/RESET_IO: U12.6; also elsewhere on the board
//RESET: R21.1, R22.2, U12.3, U12.4, U12.5; also elsewhere on the board
GND: C34.2, C35.2, C36.2, C46.2, Q3.3 (E), SW2.1, U12.7 (GND), U23.1 (GND); also elsewhere on the board
unnamed: C34.1, R16.2, SW2.2, U23.2 (TR)
unnamed: C36.1, R20.2, U23.6 (THR), U23.7 (DIS)
unnamed: D4.1 (K), R23.2
unnamed: Q3.1 (C), R23.1
unnamed: Q3.2 (B), R21.2
unnamed: U12.1, U12.2, U23.3 (Q)
VCC: C35.1, C46.1, D4.2 (A), R16.1, R20.1, R22.1, U12.14 (VCC), U23.4 (R), U23.8 (VCC); also elsewhere on the board

Parts:
C16: 33pF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C17: 33pf; C_Disc_D7.0mm_W2.5mm_P5.00mm
C18, C20, C21, C22, C23, C24, C25, C26: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C19: 220uF; CP_Radial_Tantal_D6.0mm_P2.50mm
J3: COMP_VIDEOUT; RCA
Q2: 2N3904; TO-92_Inline
R17: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18, R19: 75R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U7: TMS9918A; DIP-40_W15.24mm_LongPads
U8, U9, U10: 74LS574; DIP-20_W7.62mm_Socket_LongPads
U11: AS6C62256-55PCN; DIP-28_W15.24mm_LongPads; Manufacturer_Part_Number AS6C62256-55PCN; Mouser Part Number 913-AS6C62256-55PCN
U16: 74LS32; DIP-14_W7.62mm_LongPads
U17: 74HC04; DIP-14_W7.62mm_Socket_LongPads
Y2: 10.73MHz; Crystal_HC18-U_Vertical

Connections:
/BUS Expansion/D0: U7.24 (CD0); also elsewhere on the board
/BUS Expansion/D1: U7.23 (CD1); also elsewhere on the board
/BUS Expansion/D2: U7.22 (CD2); also elsewhere on the board
/BUS Expansion/D3: U7.21 (CD3); also elsewhere on the board
/BUS Expansion/D4: U7.20 (CD4); also elsewhere on the board
/BUS Expansion/D5: U7.19 (CD5); also elsewhere on the board
/BUS Expansion/D6: U7.18 (CD6); also elsewhere on the board
/BUS Expansion/D7: U7.17 (CD7); also elsewhere on the board
/IO/A0: U7.13 (MODE); also elsewhere on the board
/IORQ: U16.2; also elsewhere on the board
/RD: U16.5; also elsewhere on the board
/VDP_CE: U16.1; also elsewhere on the board
/VDP_INT: U7.16 (~INT); also elsewhere on the board
/VIDEO/AD0: U7.10 (AD0), U8.2 (D0), U9.2 (D0), U10.2 (D0)
/VIDEO/AD1: U7.9 (AD1), U8.3 (D1), U9.3 (D1), U10.3 (D1)
/VIDEO/AD2: U7.8 (AD2), U8.4 (D2), U9.4 (D2), U10.4 (D2)
/VIDEO/AD3: U7.7 (AD3), U8.5 (D3), U9.5 (D3), U10.5 (D3)
/VIDEO/AD4: U7.6 (AD4), U8.6 (D4), U9.6 (D4), U10.6 (D4)
/VIDEO/AD5: U7.5 (AD5), U8.7 (D5), U9.7 (D5), U10.7 (D5)
/VIDEO/AD6: U7.4 (AD6), U8.8 (D6), U9.8 (D6), U10.8 (D6)
/VIDEO/AD7: U7.3 (AD7), U8.9 (D7), U9.9 (D7), U10.9 (D7)
/VIDEO/VA0: U8.18 (Q1), U11.10 (A0)
/VIDEO/VA1: U8.17 (Q2), U11.9 (A1)
/VIDEO/VA2: U8.16 (Q3), U11.8 (A2)
/VIDEO/VA3: U8.15 (Q4), U11.7 (A3)
/VIDEO/VA4: U8.14 (Q5), U11.21 (A10)
/VIDEO/VA5: U8.13 (Q6), U11.6 (A4)
/VIDEO/VA6: U8.12 (Q7), U11.5 (A5)
/VIDEO/VA7: U9.18 (Q1), U11.23 (A11)
/VIDEO/VA8: U9.17 (Q2), U11.4 (A6)
/VIDEO/VA9: U9.16 (Q3), U11.3 (A7)
/VIDEO/VA10: U9.15 (Q4), U11.24 (A9)
/VIDEO/VA11: U9.14 (Q5), U11.2 (A12)
/VIDEO/VA12: U9.13 (Q6), U11.25 (A8)
/VIDEO/VA13: U9.12 (Q7), U11.26 (A13)
/VIDEO/VD0: U7.32 (RD0), U10.19 (Q0), U11.11 (DQ0)
/VIDEO/VD1: U7.31 (RD1), U10.18 (Q1), U11.12 (DQ1)
/VIDEO/VD2: U7.30 (RD2), U10.17 (Q2), U11.13 (DQ2)
/VIDEO/VD3: U7.29 (RD3), U10.16 (Q3), U11.15 (DQ3)
/VIDEO/VD4: U7.28 (RD4), U10.15 (Q4), U11.16 (DQ4)
/VIDEO/VD5: U7.27 (RD5), U10.14 (Q5), U11.17 (DQ5)
/VIDEO/VD6: U7.26 (RD6), U10.13 (Q6), U11.18 (DQ6)
/VIDEO/VD7: U7.25 (RD7), U10.12 (Q7), U11.19 (DQ7)
/VIDEO//CAS: U7.2 (~CAS), U11.20 (CE#), U17.9
/VIDEO//CSR: U7.15 (~CSR), U16.6
/VIDEO//CSW: U7.14 (~CSW), U16.8
/VIDEO//RAS: U7.1 (~RAS), U17.1
/WR: U16.10; also elsewhere on the board
//RESET: U7.34 (~RESET/SYNC); also elsewhere on the board
GND: C16.1, C17.1, C18.1, C20.2, C21.2, C22.1, C23.1, C24.1, C25.1, C26.1, J3.2 (Ext), R17.2, R18.2, U7.12 (VSS), U8.1 (OE), U8.10 (GND), U9.1 (OE), U9.10 (GND), U10.10 (GND), U11.1 (A14), U11.14 (VSS), U16.7 (GND), U17.7 (GND); also elsewhere on the board
unnamed: C16.2, U7.39 (XTAL1), Y2.1
unnamed: C17.2, U7.40 (XTAL2), Y2.2
unnamed: C19.1, R19.1
unnamed: C19.2, J3.1 (In)
unnamed: Q2.1 (E), R18.1, R19.2
unnamed: Q2.2 (B), R17.1, U7.36 (COMVID)
unnamed: U7.11 (R/~W), U10.1 (OE), U11.27 (WE#), U17.11
unnamed: U10.11 (Cp), U11.22 (OE#), U17.10
unnamed: U16.3, U16.4, U16.9
unnamed: U8.11 (Cp), U17.2
unnamed: U17.3, U17.8
unnamed: U17.4, U17.5
unnamed: U9.11 (Cp), U17.6
VCC: C18.2, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, Q2.3 (C), U7.33 (VCC), U8.20 (VCC), U9.20 (VCC), U10.20 (VCC), U11.28 (VCC), U16.14 (VCC), U17.14 (VCC); also elsewhere on the board

Parts:
C28, C29: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C30: 300pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C31: 2uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C32: 0.1uF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C33: 0.05uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C42: 10uF; CP_Radial_D5.0mm_P2.00mm
C43: 250uF; CP_Radial_D6.3mm_P2.50mm
J7: KEYBOARD_HEADER; PinHeader_1x20_P2.54mm_Vertical
R12: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 500; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SPEAKER1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
U20: 74LS02; DIP-14_W7.62mm_Socket_LongPads
U21: AY-3-8910; DIP-40_W15.24mm_LongPads
U22: LM386; DIP-8_W7.62mm_LongPads

Connections:
/BUS Expansion/D0: U21.37 (DA0); also elsewhere on the board
/BUS Expansion/D1: U21.36 (DA1); also elsewhere on the board
/BUS Expansion/D2: U21.35 (DA2); also elsewhere on the board
/BUS Expansion/D3: U21.34 (DA3); also elsewhere on the board
/BUS Expansion/D4: U21.33 (DA4); also elsewhere on the board
/BUS Expansion/D5: U21.32 (DA5); also elsewhere on the board
/BUS Expansion/D6: U21.31 (DA6); also elsewhere on the board
/BUS Expansion/D7: U21.30 (DA7); also elsewhere on the board
/IO/A0: U20.2; also elsewhere on the board
/PSG_CE: U20.3, U20.5; also elsewhere on the board
/SOUND/COL0: J7.12, U21.21 (IOA0)
/SOUND/COL1: J7.11, U21.20 (IOA1)
/SOUND/COL2: J7.10, U21.19 (IOA2)
/SOUND/COL3: J7.5, U21.18 (IOA3)
/SOUND/COL4: J7.8, U21.17 (IOA4)
/SOUND/COL5: J7.7, U21.16 (IOA5)
/SOUND/COL6: J7.6, U21.15 (IOA6)
/SOUND/COL7: J7.9, U21.14 (IOA7)
/SOUND/ROW0: J7.13, U21.13 (IOB0)
/SOUND/ROW1: J7.19, U21.12 (IOB1)
/SOUND/ROW2: J7.18, U21.11 (IOB2)
/SOUND/ROW3: J7.17, U21.10 (IOB3)
/SOUND/ROW4: J7.16, U21.9 (IOB4)
/SOUND/ROW5: J7.15, U21.8 (IOB5)
/SOUND/ROW6: J7.14, U21.7 (IOB6)
/SOUND/ROW7: J7.20, U21.6 (IOB7)
/WR: U20.6; also elsewhere on the board
/XTAL: U21.22 (CLK); also elsewhere on the board
//RESET: U21.23 (/RESET); also elsewhere on the board
GND: C28.1, C29.2, C30.2, C32.2, C42.2, J7.1, R12.1, R14.1, R15.1, SPEAKER1.1, U20.7 (GND), U21.1 (VSS), U21.24 (A9), U22.2 (-), U22.4 (GND); also elsewhere on the board
unnamed: C30.1, C31.2, R13.1, R14.2
unnamed: C31.1, U22.3 (+)
unnamed: C33.1, C43.1, U22.5
unnamed: C33.2, R15.2
unnamed: C43.2, SPEAKER1.2
unnamed: R12.2, R13.2, U21.3 (ACH_B), U21.4 (ACH_A), U21.38 (ACH_C)
unnamed: U20.1, U21.29 (BC1)
unnamed: U20.4, U21.27 (BDIR)
VCC: C28.2, C29.1, C32.1, C42.1, U20.14 (VCC), U21.25 (A8), U21.28 (BC2), U21.40 (VCC), U22.6 (V+); also elsewhere on the board
