# Repository tomeucapo/z80miniframe (continued)

## KiCad design schematics/Z80Mini/Z80MiniFrame-Sound_Graphics/Z80MiniFrame-Sound_Graphics.kicad_pcb (continued)

Board: 2 copper layers, 194.3 x 105.4 mm, 50 parts (0 on the bottom side), 99 nets.

## Commit log

2019-08-17 Adjust style code
2019-08-31 Added AY-3-8910 simple routine
2019-09-03 Added new schematics for graphics and sound card
2019-09-05 Latest graphics and sound card schematic and PCB modifications
2019-09-10 Latest modifications on Graphics-Sound card
2019-10-19 Latest modifications
2019-12-12 Latest modifications and update to v1.1 and first successifully VDP routines test.
2019-12-29 Added new code for core written in C with Z88DK
2019-12-29 Modified gitignore
2020-02-05 Testing C routines for VDP and keyboard. Generated backplane gerber files
2020-07-04 Latest changes on vdp routines and bas32k added new COLOR instruction
2020-07-06 Latest modifications on firmware and VDP sys calls
2020-07-08 Solved CLS code on VDP routines
2020-07-08 Moved hex files to bin directory
2020-07-18 Latest changes
2020-07-18 Latest tests on scroll routine
2020-07-18 Solved bug on text scrollup VDP routine.
2020-07-19 ADded some NOPs after VPD RAM Write and change RLA for SLA A to calculate real color VDP code.
2020-07-20 Removed unecessari test files and garbage code
2020-07-20 Edited README.md file
2020-07-25 Created new schematic for TTLSerial to USB, I2C and RS232
2020-07-26 Solve bug with delete characters on video console, also solved bug into READ_CHARACTER
2020-07-26 Add schematics PDF format
2020-07-28 Solved LOCATE BASIC keyword definition mistake
2020-07-28 Modified README file
2020-07-28 Latest improvements on realocation BASIC WRKSPC vars
2020-08-04 Adding cursor apparence on screen
2020-08-04 Changed origin X to 1 meanwhile solving screen location issues
2020-08-12 Latest changes and added CTC initialization and routine to flash cursor
2020-09-24 Latest code changes and modified Makefile to support burn to EPROM Emulator
2021-01-01 Added correct support to VDP Graphics mode 1 and updgraded COLOR BASIC instruction to support this and change border color on this mode.
2021-03-06 Created WRITE_VIDEO_LOC and WRITE_VIDEO_LOC routines into VDP library
2021-12-23 Latest changes on reserved word tokens bugfixes
2022-02-01 Added new code developed for SDCC, its a alpha stage
2022-02-01 First version of sdcc code
2022-03-30 Creating PSG library to manage AY-3-8910 sound processor
2022-04-29 Added monitor code and trying final hex file generation to burn it and test
2022-04-29 Changed README
2022-05-11 Added latest hex file stable firmware 2021 version
2022-05-11 Added firmware service routine dispacher
2022-05-13 Added new exceptions into gitignore
2022-05-14 First commit from refactored code to different modules with zmac
2022-05-15 Latest code refactor
2022-05-15 Deleted unused asm files
2022-05-17 Boot with BASIC by default
2022-05-29 Create driver to read keyboard
2022-05-30 Testing and developing keyboard driver
2022-05-31 Latest code changes and commented code
2022-05-31 Separate BASIC declarations into inc file and removed org statement
2022-05-31 Commented CALL BASIC statement temporary
2022-06-01 Added PSG support welcome test sound. Testing keyboard module
2022-06-01 Latest changes for SDCC migration. I hold this branch and work with zmac_modules and intense development to these branch
2022-06-01 Latest changes and tests with psg module
2022-06-02 Change keyboard driver to use PSG IO to scan keyboard matrix
2022-06-03 Solved some issues on VDP Mode 1 scroll up and cursor issues
2022-06-03 Changed mode 1 character set to MSX international charset
2022-06-04 Improvement of keyboard driver, creating SHIFT key pressing processing (lower and uppercase)
2022-06-04 Latest keyboard module, test KB_READKEY routine to wait key press
2022-06-05 Implement VPEEK
2022-06-07 Latest code improvements
2022-06-12 Put license terms of parts of code that owners is Leonardo Milliani
2022-06-24 Latest code changes and created new module to emulate interrupt mode 2 with vector interrupts
2022-06-24 Changed some parts of code and added new hardware module to emulate IM 2 and vector interrpt without Z80 dasy chain
2022-07-01 Changed mode 0 text charset to MSX international charset same as 8x8. Added new BASIC features: GetKey function, PSET instruction
2022-07-02 Tested VDP_PLOT routine from BASIC and works fine, now we test LINE routine
2022-07-15 Added code to save BASIC program to casette tape with 6-bit DAC and FSK modulation
2022-08-03 Added new schematics for all-in-one microcomputer board
2022-08-03 Latest all in one PCB improvements
2022-08-06 Latest modifications of All-in-one PCB
2022-08-30 Latest changes for adapt source to support Z80AllInOne adding some macros and latest schematic improvements
2022-09-01 Latest code and schematic updates. Changed IDE connector to 2.54mm IDE connector
2022-09-29 Added IM 2 based routines software support
2023-01-14 Latest changes and replace CTC for 8253 PIT
2023-04-17 Created new macro for LOADCNT PIT counter reset and removed old CTC routines that not used.
