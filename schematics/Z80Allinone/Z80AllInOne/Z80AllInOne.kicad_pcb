# Repository tomeucapo/z80miniframe (continued)

## KiCad design schematics/Z80Mini/Z80Mini.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C7, C13, C19: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C16: 10uF; CP_Radial_D5.0mm_P2.50mm
D3, D4: LED; LED_D3.0mm
J1: Conn_02x20_Odd_Even; Connector_CardEdge_40
J2: TTL Serial; PinHeader_1x06_P2.54mm_Vertical
Q1: BC337; TO-92_Inline
R2: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5, R6: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 330R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RESET; SW_PUSH_6mm_H5mm
U1: Z80CPU; DIP-40_W15.24mm_LongPads
U2: TC55257CPI; DIP-28_W15.24mm_LongPads
U3: 28C256; DIP-28_W15.24mm_LongPads
U4: NE555; DIP-8_W7.62mm_LongPads
U5: 74HC14; DIP-14_W7.62mm_LongPads
U6: 74LS139; DIP-16_W7.62mm_LongPads
X1: 4MHz; Oscillator_DIP-8

Connections:
+5V: C1.1, C2.2, C3.2, C5.2, C6.1, C7.2, C13.2, D4.2 (A), J1.9, J2.1, R2.1, R3.1, R4.1, R5.1, R6.1, R10.2, R17.1, U1.11 (VCC), U2.28 (VDD), U3.27 (~WE), U3.28 (VCC), U4.4 (R), U4.8 (VCC), U5.14 (VCC), U6.16 (VCC), X1.8 (Vcc); also elsewhere on the board
/A0: J1.19, U1.30 (A0), U2.10 (A0), U3.10 (A0); also elsewhere on the board
/A1: J1.20, U1.31 (A1), U2.9 (A1), U3.9 (A1); also elsewhere on the board
/A2: J1.21, U1.32 (A2), U2.8 (A2), U3.8 (A2); also elsewhere on the board
/A3: J1.22, U1.33 (A3), U2.7 (A3), U3.7 (A3)
/A4: J1.23, U1.34 (A4), U2.6 (A4), U3.6 (A4), U6.2 (B)
/A5: J1.24, U1.35 (A5), U2.5 (A5), U3.5 (A5), U6.3 (A)
/A6: J1.25, U1.36 (A6), U2.4 (A6), U3.4 (A6)
/A7: J1.26, U1.37 (A7), U2.3 (A7), U3.3 (A7)
/A8: J1.27, U1.38 (A8), U2.25 (A8), U3.25 (A8)
/A9: J1.28, U1.39 (A9), U2.24 (A9), U3.24 (A9)
/A10: J1.29, U1.40 (A10), U2.21 (A10), U3.21 (A10)
/A11: J1.30, U1.1 (A11), U2.23 (A11), U3.23 (A11)
/A12: J1.31, U1.2 (A12), U2.2 (A12), U3.2 (A12)
/A13: J1.37, U1.3 (A13), U2.26 (A13), U3.26 (A13)
/A14: J1.38, U1.4 (A14), U2.1 (A14), U3.1 (A14)
/A15: J1.39, U1.5 (A15), U6.14 (B)
/BUSACK: J1.32, U1.23 (~BUSACK~)
/BUSRQ: J1.35, R6.2, U1.25 (~BUSRQ~)
/D0: J1.10, U1.14 (D0), U2.11 (I/O1), U3.11 (D0); also elsewhere on the board
/D1: J1.11, U1.15 (D1), U2.12 (I/O2), U3.12 (D1); also elsewhere on the board
/D2: J1.12, U1.12 (D2), U2.13 (I/O3), U3.13 (D2); also elsewhere on the board
/D3: J1.13, U1.8 (D3), U2.15 (I/O4), U3.15 (D3); also elsewhere on the board
/D4: J1.14, U1.7 (D4), U2.16 (I/O5), U3.16 (D4); also elsewhere on the board
/D5: J1.15, U1.9 (D5), U2.17 (I/O6), U3.17 (D5); also elsewhere on the board
/D6: J1.16, U1.10 (D6), U2.18 (I/O7), U3.18 (D6); also elsewhere on the board
/D7: J1.17, U1.13 (D7), U2.19 (I/O8), U3.19 (D7); also elsewhere on the board
/DSR: J2.5; also elsewhere on the board
/DTR: J2.3; also elsewhere on the board
/INT: J1.40, U1.16 (~INT~), U5.6
/IORQ: J1.6, U1.20 (~IORQ~), U6.1 (~EN)
/IO_UART/IO_CE: U6.4 (~Q0); also elsewhere on the board
/IO_UART/UART_CE: U6.5 (~Q1); also elsewhere on the board
/IO_UART/UART_INTR: U5.5; also elsewhere on the board
/M1: J1.7, U1.27 (~M1~)
/OSC: U1.6 (~CLK~), X1.5 (OUT); also elsewhere on the board
/RESET: J1.5, R15.1, R17.2, U1.26 (~RESET~), U5.2, U5.3
/RX: J2.6; also elsewhere on the board
/SND_SEL: J1.36, U6.7 (~Q3)
/TX: J2.4; also elsewhere on the board
/VDP_SEL: J1.33, U6.6 (~Q2)
GND: C1.2, C2.1, C3.1, C5.1, C6.2, C7.1, C13.1, C16.2, C19.2, D3.1 (K), J1.34, J2.2, Q1.3 (E), SW1.1, U1.29 (GND), U2.14 (GND), U3.14 (GND), U4.1 (GND), U5.7 (GND), U6.8 (GND), U6.13 (A), X1.4 (GND); also elsewhere on the board
HALT: J1.3, U1.18 (~HALT~)
IO_RESET: U5.4; also elsewhere on the board
MREQ: J1.1, U1.19 (~MREQ~), U6.15 (~EN)
NMI: J1.2, R4.2, U1.17 (~NMI~)
unnamed: C16.1, R3.2, U4.6 (THR), U4.7 (DIS)
unnamed: C19.1, R2.2, SW1.2, U4.2 (TR)
unnamed: D3.2 (A), R10.1
unnamed: D4.1 (K), R16.2
unnamed: Q1.1 (C), R16.1
unnamed: Q1.2 (B), R15.2
unnamed: U2.20 (/CE), U6.11 (~Q1)
unnamed: U3.20 (~CS), U6.12 (~Q0)
unnamed: U4.3 (Q), U5.1
RD: J1.8, U1.21 (~RD~), U2.22 (/OE), U3.22 (~OE); also elsewhere on the board
WAIT: J1.4, R5.2, U1.24 (~WAIT~)
WR: J1.18, U1.22 (~WR~), U2.27 (R/W); also elsewhere on the board

Notes on the sheet:
Z80MiniFrame CPU and memory
2.0
08/06/2020

Parts:
C4, C20: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C8, C9, C15, C17: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C10: 0.47uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C11, C12: 47pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C14: 10uF; CP_Radial_D5.0mm_P2.50mm
D1, D2: LED; LED_D3.0mm
FB1: 600Ohm; L_0805_2012Metric
J3: USB_B_Micro; USB_Mini-B_Lumberg_2486_01_Horizontal
J4: Conn_02x10_Counter_Clockwise; IDC-Header_2x10_P2.54mm_Horizontal
JP3: USB_VBUS; PinHeader_1x02_P2.54mm_Vertical
JP4: SELF_POWER; PinHeader_1x03_P2.54mm_Vertical
Q2: IRLML6402; SOT-23
R8, R9, R11, R12, R13, R14: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW2: SW_DIP_x04; DIP-8_W7.62mm_LongPads
U7: 82C55A; DIP-40_W15.24mm_LongPads
U8: 16550; DIP-40_W15.24mm_LongPads
U9: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+5V: C8.2, C9.2, C17.2, J4.1, JP4.2, SW2.5, SW2.6, SW2.7, SW2.8, U7.26 (VCC), U8.12 (CS0), U8.13 (CS1), U8.39 (~RI~), U8.40 (VCC), U9.19 (~RESET~); also elsewhere on the board
/A0: U7.9 (A0), U8.28 (A0); also elsewhere on the board
/A1: U7.8 (A1), U8.27 (A1); also elsewhere on the board
/A2: U8.26 (A2); also elsewhere on the board
/D0: U7.34 (D0), U8.1 (D0); also elsewhere on the board
/D1: U7.33 (D1), U8.2 (D1); also elsewhere on the board
/D2: U7.32 (D2), U8.3 (D2); also elsewhere on the board
/D3: U7.31 (D3), U8.4 (D3); also elsewhere on the board
/D4: U7.30 (D4), U8.5 (D4); also elsewhere on the board
/D5: U7.29 (D5), U8.6 (D5); also elsewhere on the board
/D6: U7.28 (D6), U8.7 (D6); also elsewhere on the board
/D7: U7.27 (D7), U8.8 (D7); also elsewhere on the board
/DSR: U8.37 (~DSR~), U8.38 (~DCD~), U9.2 (DTR); also elsewhere on the board
/DTR: U8.33 (~DTR~), U9.9 (DCR), U9.10 (DCD); also elsewhere on the board
/IO_UART/IO_CE: U7.6 (~CS~); also elsewhere on the board
/IO_UART/PA4: J4.14, U7.40 (PA4)
/IO_UART/PA5: J4.13, U7.39 (PA5)
/IO_UART/PA6: J4.12, U7.38 (PA6)
/IO_UART/PA7: J4.11, U7.37 (PA7)
/IO_UART/PB0: J4.20, U7.18 (PB0)
/IO_UART/PB1: J4.19, U7.19 (PB1)
/IO_UART/PB4: J4.18, U7.22 (PB4)
/IO_UART/PB5: J4.17, U7.23 (PB5)
/IO_UART/PB6: J4.16, U7.24 (PB6)
/IO_UART/PB7: J4.15, U7.25 (PB7)
/IO_UART/PC0: J4.2, U7.14 (PC0)
/IO_UART/PC1: J4.3, U7.15 (PC1)
/IO_UART/PC2: J4.4, U7.16 (PC2)
/IO_UART/PC3: J4.5, U7.17 (PC3)
/IO_UART/PC4: J4.6, U7.13 (PC4)
/IO_UART/PC5: J4.7, U7.12 (PC5)
/IO_UART/PC6: J4.8, U7.11 (PC6)
/IO_UART/PC7: J4.9, U7.10 (PC7)
/IO_UART/UART_CE: U8.14 (~CS2~); also elsewhere on the board
/IO_UART/UART_INTR: U8.30 (INTR); also elsewhere on the board
/OSC: U8.16 (XIN); also elsewhere on the board
/RX: U8.10 (SIN), U9.1 (TXD); also elsewhere on the board
/TX: U8.11 (SOUT), U9.5 (RXD); also elsewhere on the board
GND: C8.1, C9.1, C10.2, C11.1, C12.1, C14.2, C15.2, C17.1, C20.1, D1.1 (K), D2.1 (K), J3.5 (GND), J4.10, R11.2, R12.2, R13.2, R14.2, U7.7 (GND), U8.19 (WR), U8.20 (GND), U8.22 (RD), U8.25 (~ADS~), U9.7 (GND), U9.18 (GND), U9.21 (GND), U9.25 (AGND), U9.26 (TEST); also elsewhere on the board
IO_RESET: U7.35 (RESET), U8.35 (MR); also elsewhere on the board
unnamed: C4.1, Q2.1 (G), R18.2
unnamed: C10.1, J3.6 (Shield)
unnamed: C11.2, J3.2 (D-), U9.16 (USBD-)
unnamed: C12.2, J3.3 (D+), U9.15 (USBD+)
unnamed: C14.1, FB1.2, JP3.1
unnamed: C15.1, U9.17 (3V3OUT)
unnamed: C4.2, C20.2, JP4.1, Q2.3 (D)
unnamed: D1.2 (A), R8.1
unnamed: D2.2 (A), R9.1
unnamed: FB1.1, JP4.3, Q2.2 (S), U9.4 (VCCIO), U9.20 (VCC)
unnamed: J3.1 (VBUS), JP3.2
unnamed: R8.2, U7.20 (PB2)
unnamed: R9.2, U7.21 (PB3)
unnamed: R11.1, SW2.1, U7.4 (PA0)
unnamed: R12.1, SW2.2, U7.3 (PA1)
unnamed: R13.1, SW2.3, U7.2 (PA2)
unnamed: R14.1, SW2.4, U7.1 (PA3)
unnamed: R18.1, U9.14 (CBUS3)
unnamed: U8.9 (RCLK), U8.15 (~BAUDOUT~)
unnamed: U8.32 (~RTS~), U9.11 (CTS)
unnamed: U8.36 (~CTS~), U9.3 (RTS)
RD: U7.5 (~RD~), U8.21 (~RD~); also elsewhere on the board
WR: U7.36 (~WR~), U8.18 (~WR~); also elsewhere on the board

Notes on the sheet:
Mini Z80 IO Module
05/08/2019

Board: 2 copper layers, 194.3 x 105.4 mm, 64 parts (0 on the bottom side), 97 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3_DIN965_Pad

Their connections:
GND: REF2.4, REF4.3; also elsewhere on the board

## KiCad design schematics/Z80Mini/Z80MiniFrame-Sound_Graphics/Z80MiniFrame-Sound_Graphics.kicad_pcb

Parts:
J1: Conn_02x20_Odd_Even; Connector_CardEdge_40
JP3: Jumper_NC_Dual; PinHeader_1x03_P2.00mm_Vertical

Connections:
/D0: J1.10; also elsewhere on the board
/D1: J1.11; also elsewhere on the board
/D2: J1.12; also elsewhere on the board
/D3: J1.13; also elsewhere on the board
/D4: J1.14; also elsewhere on the board
/D5: J1.15; also elsewhere on the board
/D6: J1.16; also elsewhere on the board
/D7: J1.17; also elsewhere on the board
/graphicsProcessor/A0: J1.19; also elsewhere on the board
/graphicsProcessor/INT: JP3.2; also elsewhere on the board
/graphicsProcessor/IORQ: J1.6; also elsewhere on the board
/graphicsProcessor/RD: J1.8; also elsewhere on the board
/graphicsProcessor/RESET: J1.5; also elsewhere on the board
/graphicsProcessor/VD_SEL: J1.33; also elsewhere on the board
/graphicsProcessor/WR: J1.18; also elsewhere on the board
/soundGeneration/SND_SEL: J1.36; also elsewhere on the board
GND: J1.34; also elsewhere on the board
unnamed: J1.2, JP3.3
unnamed: J1.40, JP3.1
VCC: J1.9; also elsewhere on the board

Parts:
C8, C9, C10, C11, C12, C13, C19, C22: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C16: 33pf; C_Disc_D7.0mm_W2.5mm_P5.00mm
C17: 33pF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C18: 220uF; CP_Radial_Tantal_D6.0mm_P2.50mm
CV1: 5-50pF; Potentiometer_ACP_CA9-V10_Vertical
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J2: COMP_VIDEOUT; RCA_Female_902
J5: COMP_VIDEOIN; RCA_Female_902
Q1: 2N3904; TO-92_Inline
R10, R12: 75R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: TMS9918A; DIP-40_W15.24mm_LongPads
U2, U3, U4: 74LS574; DIP-20_W7.62mm_Socket_LongPads
U5: AS6C62256-55PCN; DIP-28_W15.24mm_LongPads; Manufacturer_Part_Number AS6C62256-55PCN; Mouser Part Number 913-AS6C62256-55PCN
U6: 74HC04; DIP-14_W7.62mm_Socket_LongPads
U12: 74LS32; DIP-14_W7.62mm_LongPads
Y1: 10.73MHz; Crystal_HC18-U_Vertical

Connections:
/D0: U1.17 (CD7); also elsewhere on the board
/D1: U1.18 (CD6); also elsewhere on the board
/D2: U1.19 (CD5); also elsewhere on the board
/D3: U1.20 (CD4); also elsewhere on the board
/D4: U1.21 (CD3); also elsewhere on the board
/D5: U1.22 (CD2); also elsewhere on the board
/D6: U1.23 (CD1); also elsewhere on the board
/D7: U1.24 (CD0); also elsewhere on the board
/graphicsProcessor/A0: U1.13 (MODE); also elsewhere on the board
/graphicsProcessor/AD0: U1.10 (AD0), U2.2 (D0), U3.2 (D0), U4.2 (D0)
/graphicsProcessor/AD1: U1.9 (AD1), U2.3 (D1), U3.3 (D1), U4.3 (D1)
/graphicsProcessor/AD2: U1.8 (AD2), U2.4 (D2), U3.4 (D2), U4.4 (D2)
/graphicsProcessor/AD3: U1.7 (AD3), U2.5 (D3), U3.5 (D3), U4.5 (D3)
/graphicsProcessor/AD4: U1.6 (AD4), U2.6 (D4), U3.6 (D4), U4.6 (D4)
/graphicsProcessor/AD5: U1.5 (AD5), U2.7 (D5), U3.7 (D5), U4.7 (D5)
/graphicsProcessor/AD6: U1.4 (AD6), U2.8 (D6), U3.8 (D6), U4.8 (D6)
/graphicsProcessor/AD7: U1.3 (AD7), U2.9 (D7), U3.9 (D7), U4.9 (D7)
/graphicsProcessor/COMVID: Q1.2 (B), R11.1, U1.36 (COMVID); also elsewhere on the board
/graphicsProcessor/CPUCLK: U1.38 (CPUCLK); also elsewhere on the board
/graphicsProcessor/EXTV: J5.1 (In), U1.35 (EXTV); also elsewhere on the board
/graphicsProcessor/INT: D1.2 (A); also elsewhere on the board
/graphicsProcessor/IORQ: U12.2; also elsewhere on the board
/graphicsProcessor/RD: U12.5; also elsewhere on the board
/graphicsProcessor/RESET: U1.34 (RESET/SYNC); also elsewhere on the board
/graphicsProcessor/VA0: U2.18 (Q1), U5.10 (A0)
/graphicsProcessor/VA1: U2.17 (Q2), U5.9 (A1)
/graphicsProcessor/VA2: U2.16 (Q3), U5.8 (A2)
/graphicsProcessor/VA3: U2.15 (Q4), U5.7 (A3)
/graphicsProcessor/VA4: U2.14 (Q5), U5.21 (A10)
/graphicsProcessor/VA5: U2.13 (Q6), U5.6 (A4)
/graphicsProcessor/VA6: U2.12 (Q7), U5.5 (A5)
/graphicsProcessor/VA7: U3.18 (Q1), U5.23 (A11)
/graphicsProcessor/VA8: U3.17 (Q2), U5.4 (A6)
/graphicsProcessor/VA9: U3.16 (Q3), U5.3 (A7)
/graphicsProcessor/VA10: U3.15 (Q4), U5.24 (A9)
/graphicsProcessor/VA11: U3.14 (Q5), U5.2 (A12)
/graphicsProcessor/VA12: U3.13 (Q6), U5.25 (A8)
/graphicsProcessor/VA13: U3.12 (Q7), U5.26 (A13)
/graphicsProcessor/VD0: U1.32 (RD0), U4.19 (Q0), U5.11 (DQ0)
/graphicsProcessor/VD1: U1.31 (RD1), U4.18 (Q1), U5.12 (DQ1)
/graphicsProcessor/VD2: U1.30 (RD2), U4.17 (Q2), U5.13 (DQ2)
/graphicsProcessor/VD3: U1.29 (RD3), U4.16 (Q3), U5.15 (DQ3)
/graphicsProcessor/VD4: U1.28 (RD4), U4.15 (Q4), U5.16 (DQ4)
/graphicsProcessor/VD5: U1.27 (RD5), U4.14 (Q5), U5.17 (DQ5)
/graphicsProcessor/VD6: U1.26 (RD6), U4.13 (Q6), U5.18 (DQ6)
/graphicsProcessor/VD7: U1.25 (RD7), U4.12 (Q7), U5.19 (DQ7)
/graphicsProcessor/VD_SEL: U12.1; also elsewhere on the board
/graphicsProcessor/WR: U12.10; also elsewhere on the board
GND: C8.2, C9.2, C10.1, C11.1, C12.1, C13.1, C16.1, C17.1, C19.1, C22.1, CV1.1, J2.2 (Ext), J5.2 (Ext), R10.2, R11.2, U1.12 (VSS), U2.1 (OE), U2.10 (GND), U3.1 (OE), U3.10 (GND), U4.10 (GND), U5.1 (A14), U5.14 (VSS), U6.7 (GND), U12.7 (GND); also elsewhere on the board
unnamed: C16.2, CV1.2, U1.39 (XTAL2), Y1.2
unnamed: C17.2, U1.40 (XTAL1), Y1.1
unnamed: C18.1, R12.1
unnamed: C18.2, J2.1 (In)
unnamed: D1.1 (K), U1.16 (/INT)
unnamed: Q1.1 (E), R10.1, R12.2
unnamed: U1.1 (/RAS), U6.1
unnamed: U1.2 (/CAS), U5.20 (CE#), U6.9
unnamed: U1.11 (R/W), U4.1 (OE), U5.27 (WE#), U6.11
unnamed: U1.14 (/CSW), U12.8
unnamed: U1.15 (/CSR), U12.6
unnamed: U2.11 (Cp), U6.2
unnamed: U3.11 (Cp), U6.6
unnamed: U4.11 (Cp), U5.22 (OE#), U6.10
unnamed: U6.3, U6.8
unnamed: U6.4, U6.5
unnamed: U12.3, U12.4, U12.9
VCC: C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C19.2, C22.2, Q1.3 (C), U1.33 (VCC), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC), U5.28 (VCC), U6.14 (VCC), U12.14 (VCC); also elsewhere on the board

Parts:
C1, C14: 100nF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C2: 300pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 2uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 10uF; CP_Radial_D5.0mm_P2.00mm
C5: 0.1uF; C_Disc_D7.0mm_W2.5mm_P5.00mm
C6: 250uF; CP_Radial_D6.3mm_P2.50mm
C7: 0.05uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J3: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J4: IO_PORT; IDC-Header_2x10_P2.54mm_Vertical
JP1: PREAMP_MONO; PinHeader_2x03_P2.54mm_Vertical
JP4: Jumper_NC_Dual; PinHeader_1x03_P2.54mm_Vertical
R1: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 500; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SPEAKER1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
U7: AY-3-8910; DIP-40_W15.24mm_LongPads
U8: 74LS02; DIP-14_W7.62mm_Socket_LongPads
U9: LM386; DIP-8_W7.62mm_LongPads
X1: ACO-2MHz; Oscillator_DIP-14

Connections:
/D0: U7.37 (DA0); also elsewhere on the board
/D1: U7.36 (DA1); also elsewhere on the board
/D2: U7.35 (DA2); also elsewhere on the board
/D3: U7.34 (DA3); also elsewhere on the board
/D4: U7.33 (DA4); also elsewhere on the board
/D5: U7.32 (DA5); also elsewhere on the board
/D6: U7.31 (DA6); also elsewhere on the board
/D7: U7.30 (DA7); also elsewhere on the board
/graphicsProcessor/A0: U8.2; also elsewhere on the board
/graphicsProcessor/COMVID: J4.19; also elsewhere on the board
/graphicsProcessor/CPUCLK: JP4.1; also elsewhere on the board
/graphicsProcessor/EXTV: J4.20; also elsewhere on the board
/graphicsProcessor/RESET: U7.23 (/RESET); also elsewhere on the board
/soundGeneration/SND_SEL: U8.3, U8.5, U8.6; also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, C14.1, J4.18, R1.1, R3.1, R4.1, SPEAKER1.1, U7.1 (VSS), U7.24 (A9), U8.7 (GND), U9.2 (-), U9.4 (GND), X1.7 (GND); also elsewhere on the board
unnamed: C2.1, C3.2, R2.1, R3.2
unnamed: C3.1, U9.3 (+)
unnamed: C6.1, C7.1, U9.5
unnamed: C6.2, SPEAKER1.2
unnamed: C7.2, R4.2
unnamed: J3.1, JP1.2, U7.38 (ACH_C)
unnamed: J3.2, JP1.4, U7.3 (ACH_B)
unnamed: J3.3, JP1.6, U7.4 (ACH_A)
unnamed: J4.1, U7.21 (IOA0)
unnamed: J4.2, U7.13 (IOB0)
unnamed: J4.3, U7.20 (IOA1)
unnamed: J4.4, U7.12 (IOB1)
unnamed: J4.5, U7.19 (IOA2)
unnamed: J4.6, U7.11 (IOB2)
unnamed: J4.7, U7.18 (IOA3)
unnamed: J4.8, U7.10 (IOB3)
unnamed: J4.9, U7.17 (IOA4)
unnamed: J4.10, U7.9 (IOB4)
unnamed: J4.11, U7.16 (IOA5)
unnamed: J4.12, U7.8 (IOB5)
unnamed: J4.13, U7.15 (IOA6)
unnamed: J4.14, U7.7 (IOB6)
unnamed: J4.15, U7.14 (IOA7)
unnamed: J4.16, U7.6 (IOB7)
unnamed: JP1.1, JP1.3, JP1.5, R1.2, R2.2
unnamed: JP4.2, U7.22 (CLK)
unnamed: JP4.3, X1.8 (OUT)
unnamed: U7.27 (BDIR), U8.4
unnamed: U7.29 (BC1), U8.1
VCC: C1.1, C4.1, C5.1, C14.2, J4.17, U7.25 (A8), U7.28 (BC2), U7.40 (VCC), U8.14 (VCC), U9.6 (V+), X1.14 (Vcc); also elsewhere on the board
